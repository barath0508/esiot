# Keil uVision project matrix_7seg.uvproj, settings and files
target Target 1 (5040049::V5.04 update 1 (build 49)::ARMCC)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: matrix_7seg +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s matrix_7seg_driver.c main.c defs.h mat_7seg.h
